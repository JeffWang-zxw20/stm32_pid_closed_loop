# Keil uVision project TypeA.uvprojx, settings and files
target TypeA (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: TypeA +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F405xx,ARM_MATH_CM4,__CC_ARM
  c include: ..\Code\Drivers\CMSIS\Include;..\Code\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\Code\Drivers\STM32F4xx_HAL_Driver\Inc;..\Code\Drivers\BSP\Inc;..\Code\Main\Inc;..\Code\Device\Inc;..\Code\Module\Inc;..\Code\Tools\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Drivers/STM32F4xx_HAL_Driver
    ../Code/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_crc.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c
  group Drivers/CMSIS
    ../Code/Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../Code/Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f405xx.s
    ../Code/Drivers/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group Drivers/BSP
    ../Code/Drivers/BSP/Src/: bsp.c can.c clk.c dma.c gpio.c iwdg.c led.c stm32f4xx_hal_msp.c stm32f4xx_it.c tim.c usart.c
  group Device
    ../Code/Device/Src/: dbus.c encoder.c motor.c
  group Tools
    ../Code/Tools/Src/: ANO.c pid.c
  group Main
    ../Code/Main/Src/: main.c test.c host.c control.c
software components: CMSIS:CORE 4.3.0
