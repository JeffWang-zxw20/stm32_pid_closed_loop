# Keil uVision project Project_AS3x5x6x.uvprojx, settings and files
target AS62 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project_AS62 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Source_Files\drv_mcu\inc;.\Source_Files\Std_lib\inc;.\Source_Files\Std_lib\startup;.\Source_Files\drv_periph\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ./Source_Files/app/: main.c
  group drv_muc
    ./Source_Files/drv_mcu/src/: drv_delay.c drv_led.c drv_uart.c
  group std_lib
    ./Source_Files/Std_lib/src/: core_cm3.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c system_stm32f10x.c
    ./Source_Files/Std_lib/startup/: startup_stm32f10x_hd.s
  group drv_periph
    ./Source_Files/drv_periph/src/: drv_AS62.c
